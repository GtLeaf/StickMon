// SPDX-License-Identifier: Apache-2.0
#pragma once
#include <cstdint>
#include <cstddef>
// Tiny independent 5x7 alphabet. Recovery must work without any resource fonts.
namespace RecoveryText {
inline constexpr uint8_t LETTERS[][5]={
 {0x7e,0x11,0x11,0x11,0x7e},{0x7f,0x49,0x49,0x49,0x36},{0x3e,0x41,0x41,0x41,0x22},
 {0x7f,0x41,0x41,0x22,0x1c},{0x7f,0x49,0x49,0x49,0x41},{0x7f,0x09,0x09,0x09,0x01},
 {0x3e,0x41,0x49,0x49,0x7a},{0x7f,0x08,0x08,0x08,0x7f},{0,0x41,0x7f,0x41,0},
 {0x20,0x40,0x41,0x3f,0x01},{0x7f,0x08,0x14,0x22,0x41},{0x7f,0x40,0x40,0x40,0x40},
 {0x7f,0x02,0x0c,0x02,0x7f},{0x7f,0x04,0x08,0x10,0x7f},{0x3e,0x41,0x41,0x41,0x3e},
 {0x7f,0x09,0x09,0x09,0x06},{0x3e,0x41,0x51,0x21,0x5e},{0x7f,0x09,0x19,0x29,0x46},
 {0x46,0x49,0x49,0x49,0x31},{0x01,0x01,0x7f,0x01,0x01},{0x3f,0x40,0x40,0x40,0x3f},
 {0x1f,0x20,0x40,0x20,0x1f},{0x3f,0x40,0x38,0x40,0x3f},{0x63,0x14,0x08,0x14,0x63},
 {0x07,0x08,0x70,0x08,0x07},{0x61,0x51,0x49,0x45,0x43}
};
template<class Plot> void draw(int x,int y,const char* text,uint16_t color,Plot plot,unsigned scale=2) {
    if(!text || !scale)return;
    const int start=x;
    for(;*text;++text,x+=6*int(scale)) {
        char c=*text;if(c>='a' && c<='z')c-=32;
        if(c=='\n') {x=start-6*int(scale);y+=9*int(scale);continue;}
        if(c==' ')continue;
        for(unsigned col=0;col<5;++col) {
            uint8_t bits=c>='A' && c<='Z'?LETTERS[c-'A'][col]:c=='-'?8:c=='.'?(col==2?64:0):0x7f;
            for(unsigned row=0;row<7;++row) if(bits&(1<<row))
                for(unsigned dy=0;dy<scale;++dy)for(unsigned dx=0;dx<scale;++dx)
                    plot(x+int(col*scale+dx),y+int(row*scale+dy),color);
        }
    }
}
}
